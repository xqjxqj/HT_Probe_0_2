# Keil uVision project HT_Probe_0_2.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HT_Probe_0_2
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Users;.\Users\Driver;.\Users\Driver\RV-3029-C2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group UsersApp
    ./Users/: ringbuffer.c UserApp.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32G474VETx/STCubeGenerated/Src/: main.c stm32g4xx_it.c
    ./RTE/Device/STM32G474VETx/STCubeGenerated/Inc/: stm32g4xx_it.h
  group UserDiver
    ./Users/Driver/: user_usart.c
    ./Users/Driver/RV-3029-C2/: RV-3029-C2.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube HAL 1.4.0
